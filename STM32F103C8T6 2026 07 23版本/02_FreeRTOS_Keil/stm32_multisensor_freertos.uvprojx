# Keil uVision project stm32_multisensor_freertos.uvprojx, settings and files
target FreeRTOS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: stm32_multisensor_freertos +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xB,USE_HAL_DRIVER,APP_UI_DEFAULT_THEME=0,APP_UI_PROFILE_ID=0
  c misc: --c99 --gnu
  c include: .\Core\Inc;.\App\Inc;.\Drivers\STM32F1xx_HAL_Driver\Inc;.\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;.\Drivers\CMSIS\Device\ST\STM32F1xx\Include;.\Drivers\CMSIS\Include;.\Middlewares\Third_Party\FreeRTOS\Source\include;.\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Core
    ./Core/Src/: main.c board.c stm32f1xx_it.c
    ./Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ./Core/Startup/arm/: startup_stm32f103xb.s
  group Application
    ./App/Src/: bh1750.c bmp280.c buzzer.c crc32.c debug_log.c ds3231.c encoder.c sensor_service.c sht30.c ssd1306.c storage_service.c ui_service.c w25q64.c ui_theme_nokia.c
  group FreeRTOS Kernel
    ./Middlewares/Third_Party/FreeRTOS/Source/: tasks.c queue.c list.c
    ./Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group STM32 HAL
    ./Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c
target FreeRTOS-Nokia (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: stm32_multisensor_freertos_nokia +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xB,USE_HAL_DRIVER,APP_UI_DEFAULT_THEME=1,APP_UI_PROFILE_ID=1
  c misc: --c99 --gnu
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
